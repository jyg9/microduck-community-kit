# Repository jyg9/microduck-community-kit

File README.md:

# 用于Microduck复刻的一些PCB补充

> 这不是官方Microduck仓库，<a href="https://github.com/pollen-robotics/microduck">官方仓库</a>在这里，感谢他们开源。本项目是复刻所需硬件PCB补充。

微信讨论群：

主要包括：
- **imu_to_dxl**：<a href="hardware/imu_to_dxl">身体传感器板</a>、<a href="firmware/v1">对应的固件</a>和<a href="firmware/v1/host">上位机测试软件</a>。特点：高度接近原版设计、高可靠设计、固件可在线升级。
- **banana_pcb**：<a href="hardware/banana_pcb">电池上方的转接小板</a>
- **dxl_hub**：<a href="hardware/dxl_hub">鸭鸭身体中的集线器板</a>
- **飞特舵机调试软件**：<a href="software/hls_servo_debugger">飞特舵机调试软件</a>
- **microduck_feetech**：<a href="https://github.com/jyg9/microduck_ft1910">官方机器人软件（robotd 等）的飞特舵机适配版</a>——官方 `microduck` 的完整参考源码，基于0.16.0打上飞特总线补丁，IMU适配本仓库，可直接编译运行；

接线图：
```text
                               🦆 头部 (Head)
                                    │
                                    │ 舵机线
                                    ▲
 🔋 电池 (Battery)            ┌───────────┐
      │                      │           │
      │ 香蕉头                │  dxl_hub  │
      ▼                      │  (腹部)    │
 🍌 banana_pcb ─────────────>│           │
      (正负电源线)             └─┬───┬───┬─┘
                                │   │   │
                 ┌──────────────┘   │   └──────────────┐
                 │ 舵机线            │ 舵机线            │ 舵机线
                 ▼                  ▼                  ▼
            🦿 左腿            ⚖️ IMU            🦿 右腿
                             (imu_to_dxl，跨部内)
```

如需要编译固件，克隆的时候需要增加--recurse-submodules参数，否则不会下载GDLib：
```bash
git clone --recurse-submodules https://github.com/jyg9/microduck-community-kit.git
```

固件升级方法：
- 1、SFTP复制本项目<a href="firmware/v1/host">主机工具</a>下的`upgrade.py`、`package.py`、`bus.py`到目标电脑。目标电脑可也是鸭子后台，也可以是电脑接USB转舵机TTL。
- 2、从项目Releases下载编译好的固件，两个文件`gd32f303cc_imu_to_dxl_slot_a.ipkg`和`gd32f303cc_imu_to_dxl_slot_b.ipkg`，同样复制到目标电脑。
- 3、执行升级指令：
```bash
# 看目前节点版本号等信息，需不需要升级，提示缺依赖使用pip3 install <包名>安装
./upgrade.py status build/gd32f303cc_imu_to_dxl_slot_a.ipkg

# 升级指令，使用自动识别串口
./upgrade.py upgrade gd32f303cc_imu_to_dxl_slot_a.ipkg

# 升级指令，指定一些参数（高级，与上面二选一）
./upgrade.py upgrade gd32f303cc_imu_to_dxl_slot_a.ipkg --port /dev/ttyS2 --baud 1000000 --protocol auto --yes

# 如果提示slot_a占用，更换上面文件名为slot_b，目前脚本还不是十分智能

# 再检查升级后节点版本，版本号一致就是升级成功
./upgrade.py status
```

## 其他说明
 - 方案已经经过批量验证，在原版XL330舵机和飞特HD1910舵机上，都适配良好
 - 项目主要使用了中国国内易于采购的飞特1910舵机，同时兼容原版XL330
 - 本项目在Linux平台开发，不能保证其他平台兼容性
 - 硬件是纯手工绘制，软件全部由AI编写和调试
 - imu_to_dxl和dxl+hub等板子，如有需要，可在<a href="https://mduck.taobao.com">我的店铺</a>购买。
 - 如果觉得项目不错，欢迎小额打赏😀，或者点个星⭐再走？

## KiCad design hardware/dxl_hub/dxl_hub.kicad_pcb

File hardware/dxl_hub/README.md:

# "dxl_hub" 电力与数据分发板子

> "dxl_hub" 固定在机器鸭身体中舵机上方的板子。用于把电池电力分配到左右腿、头部和IMU。对单总线串口数据信号进行合并。

 - 根据需要焊接飞特1910舵机接口或XL330舵机接口，二选一。
 - 三个焊接在背面（两腿+IMU），一个正面（脖子）。
 - 物料参考型号：
   - XL330用：B3B-EH-A(LF)(SN)，立式
   - 飞特1910用：AMP175778/8283/A2007WV-3P，立式
   - 螺丝使用如下规格：

## 其他信息
 - 使用KiCAD 9设计。

Parts:
C1: 1000uF/10V固态; CAP-TH_BD8.0-P3.50-D0.5-FD; Manufacturer Part SPZ1AM102F11000RAXXX
CN1, CN3, CN5, CN7: B3B-EH-A (LF)(SN); CONN-TH_B3B-EH-A-LF-SN
CN2, CN4, CN6, CN8: B3B-PH-K-S(LF)(SN); CONN-TH_B3B-PH-K-S
J1, J2: 1.8mm螺丝孔; pad
J3: pad-2(thru)

Connections:
+BATT: C1.1, CN1.2, CN2.2, CN3.2, CN4.2, CN5.2, CN6.2, CN7.2, CN8.2, J3.1
/DATA: CN1.3, CN2.1, CN3.3, CN4.1, CN5.3, CN6.1, CN7.3, CN8.1
GND: C1.2, CN1.1, CN2.3, CN3.1, CN4.3, CN5.1, CN6.3, CN7.1, CN8.3, J3.2

Notes on the sheet:
飞特接口
上一版本发现正面焊接卧式插座(CN2、CN4)，与鸭脖子舵机有少许干涉 改为背面立式插座，正面舵机线束需要绕到背面插上
XL330接口(二选一)

Board: 2 copper layers, 22.3 x 28.2 mm, 12 parts (6 on the bottom side), 3 nets.

## KiCad design hardware/imu_to_dxl/imu_to_dxl.kicad_pcb

File hardware/imu_to_dxl/README.md:

# "imu_to_dxl" IMU转舵机协议板

> "imu_to_dxl"固定在电池背面，提供精确的机器鸭身体姿态反馈数据

功能如下：
- **供电电压**：6~24V
- **通讯方式**：舵机单总线TTL串口，3.3V电平
- **电源转换效率**：>90%

对应固件在firmware/v1目录下

## 其他信息
 - 使用KiCAD 9设计。

Parts:
C1: 100p; C0402; LCSC Part C106200
C2, C7, C8, C9, C12, C13, C14, C15, C16, C18, C19: 100nF/16V; C0402; LCSC Part C1525
C5: 22uF/6.3V; C0603; LCSC Part C59461
C6: 10uF/50V; C0805; Manufacturer Part CL21A106KBYQNNE; LCSC Part C2932476
C10, C11, C17: 20pF/50V; C0402; LCSC Part C107000
C20, C21: 1uF/10V; C0402; LCSC Part C106254
C22: 1nF/50V; C0402; LCSC Part C106205
CN1: B3B-EH-A(LF)(SN); CONN-TH_B3B-EH-A-LF-SN; not fitted
CN2: AMP175778/8283/A2007WV-3P; CONN-TH_B3B-PH-K-S; not fitted
D1: SMAJ36A; SMA_L4.4-W2.6-LS5.0-RD; LCSC Part C353452
D2: 5V ESD; SOD-323_L1.7-W1.3-LS2.5-BI; LCSC Part C19224
F1: PTC(40R); F0603; Manufacturer Part JK-SMD0603-001; LCSC Part C2687114
H1, H3: LAIL-PZ2.54-4P-L; pad-4; Manufacturer Part LAIL-PZ2.54-4P-L; LCSC Part C54950602; not fitted
H2: PZ254V-11-05P; pad-5; Manufacturer Part PZ254V-11-05P; LCSC Part C492404; not fitted
J1, J2, J3, J4: 1.8mm螺丝孔; pad; not fitted
L1: 10uH/920mA; IND-SMD_L3.0-W3.0_SWPA3010S; Manufacturer Part SWPA3015S100MT; LCSC Part C45403
LED1: GL0603UG01; LED0603-RD; Manufacturer Part GL0603UG01; LCSC Part C51933293
Q1: MMBT3906; SOT-23; LCSC Part C727128
R1: 75K; R0402; LCSC Part C144737
R2, R10, R11, R12, R13, R17, R18, R21, R22, R23, R24, R25, R26: 51R; R0402; LCSC Part C137960
R3: 100K; R0402; LCSC Part C25741
R4: 30K; R0402; LCSC Part C25776; not fitted
R5: 0R; R0603; LCSC Part C21189
R6: 24K; R0402; LCSC Part C138026
R7, R8, R15, R16, R19: 10K; R0402; LCSC Part C25744
R9, R32: 0R; R0402; LCSC Part C60485
R14, R34: 1K; R0402; LCSC Part C11702
R20: 51R; R0402; LCSC Part C137960; not fitted
R27, R28, R30: 10k; R0402; LCSC Part C25744
R29: 20k; R0402; LCSC Part C25765
R31: 100k; R0402; LCSC Part C25741
R33: 0R; R0402_Jumper; LCSC Part C60485; not fitted
R35: 1M; R0402; LCSC Part C26083
U1: ETA2845S2G_C22362741; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; Manufacturer Part ETA2845S2G; LCSC Part C22362741
U2: GD32F303CCT6; LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL; Manufacturer Part GD32F303CCT6; LCSC Part C116151
U3: LSM6DSV16XTR; LGA-14_L3.0-W2.5-P0.50-BR; Manufacturer Part LSM6DSV16XTR; LCSC Part C5267406
U4: SN74LVC1G126DBVR; SOT-23-5; LCSC Part C46472327
U5: SN74LVC1G125DBV; SOT-23-5; LCSC Part C3040625
U6: ME6211C18M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part ME6211C18M5G-N; LCSC Part C236671
X1: XL2EL89CSI-111YLC-12M; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Manufacturer Part XL2EL89CSI-111YLC-12M; LCSC Part C5280576

Connections:
+1.8VA: C21.2, R32.1, U6.5 (VOUT)
+3.3V: C1.2, C5.2, C7.2, C12.1, C13.2, C14.2, C16.2, C18.2, C19.2, C20.2, H1.1, H2.2, L1.2, Q1.2 (E), R1.2, R7.1, R8.2, R9.2, R15.2, R16.2, R20.2, R27.2, R30.2, R31.2, R33.2, U2.1 (VBAT), U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3), U3.5 (Vdd_IO), U4.5 (VCC), U5.5 (VCC), U6.1 (VIN), U6.3 (CE)
+BATT: C6.2, CN1.2, CN2.2, D1.1 (K), H3.4, R3.2, U1.5 (IN)
/DATA: CN1.3, CN2.1, F1.1
/DATA1: R5.2, R31.1, U4.4, U5.2
/DEBUG_LED: LED1.2 (A), U2.41 (PB5)
/DEBUG_RX: R7.2, R10.1, U2.43 (PB7)
/DEBUG_TX: R11.1, U2.42 (PB6)
/GD_OSCIN: C10.2, R35.2, U2.5 (PD0-OSCIN), X1.1
/GD_OSCOUT: C11.2, R35.1, U2.6 (PD1-OSCOUT), X1.3
/GD_RST: C8.2, R8.1, R14.1, U2.7 (NRST)
/GD_SWDCLK: R12.1, R15.1, U2.37 (PA14)
/GD_SWDIO: R13.1, R16.1, U2.34 (PA13)
/IMU_INT1: R25.2, U3.4 (INT1)
/IMU_INT2: R26.2, U3.9 (INT2)
/IMU_SPI_CLK: R22.2, U3.13 (SCL)
/IMU_SPI_CS: C17.2, R21.2, U3.12 (CS)
/IMU_SPI_MISO: R23.2, U3.1 (SDO/SA0)
/IMU_SPI_MOSI: R24.2, U3.14 (SDA)
/PA2_USART1_TX: R27.1, R28.1, U2.12 (PA2), U4.2
/PA3_USART1_RX: R30.1, U2.13 (PA3), U5.4
/PA4_SPI0_NSS: R21.1, U2.14 (PA4)
/PA5_SPI0_SCK: R22.1, U2.15 (PA5)
/PA6_SPI0_MISO: R23.1, U2.16 (PA6)
/PA7_SPI0_MOSI: R24.1, U2.17 (PA7)
/PB0: R25.1, U2.18 (PB0)
/PB1: R26.1, U2.19 (PB1)
/TXD_EN: C22.2, Q1.3 (C), R29.2, U4.1, U5.1
/USB_DM: H3.3, R17.2
/USB_DP: H3.2, R18.2
GND: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, CN1.1, CN2.3, D1.2 (A), D2.1, H1.2, H2.3, H3.1, R4.2, R6.1, R19.1, R29.1, R34.1, U1.2 (GND), U2.8 (VSSA), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), U3.2 (SDx/AH1/Qvar1), U3.3 (SCx/AH2/Qvar2), U3.6 (GND), U3.7 (GND), U4.3 (GND), U5.3 (GND), U6.2 (VSS), X1.2 (GND), X1.4 (GND)
unnamed: C2.1, R2.2
unnamed: D2.2, F1.2, R5.1
unnamed: H1.3, R10.2
unnamed: H1.4, R11.2
unnamed: H2.1, R14.2
unnamed: H2.4, R13.2
unnamed: H2.5, R12.2
unnamed: LED1.1 (K), R34.2
unnamed: Q1.1 (B), R28.2
unnamed: R2.1, U1.1 (BST)
unnamed: R3.1, R4.1, U1.4 (EN)
unnamed: C1.1, R1.1, R6.2, U1.3 (FB)
unnamed: C2.2, L1.1, U1.6 (SW)
unnamed: R19.2, R33.1, U2.44 (BOOT0)
unnamed: R17.1, U2.32 (PA11)
unnamed: R18.1, U2.33 (PA12)
unnamed: C9.2, R9.1, U2.9 (VDDA)
unnamed: C15.2, R20.1, R32.2, U3.8 (Vdd)

Notes on the sheet:
Debug
二选一，手工焊接
SWD
USB Download
USB Download Switch

Board: 2 copper layers, 27.1 x 30.2 mm, 77 parts (0 on the bottom side), 49 nets.

File hardware/imu_to_dxl/production/bom(hq).csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1",C0402,10,100p,C106200
"C10, C11, C17",C0402,30,27pF/50V,C107002
"C12, C13, C14, C15, C16, C18, C19, C2, C7, C8, C9",C0402,110,100nF/16V,C1525
"C20, C21",C0402,20,1uF/10V,C106254
"C22",C0402,10,1nF/50V,C106205
"C5",C0603,10,22uF/6.3V,C59461
"C6",C0805,10,10uF/50V,C2932476
"CN1",CONN-TH_B3B-EH-A-LF-SN,10,B3B-EH-A (LF)(SN),C160259
"CN2",CONN-TH_B3B-PH-K-S,10,B3B-PH-K-S(LF)(SN),C131339
"D1",SMA_L4.4-W2.6-LS5.0-RD,10,SMAJ24A,C90510
"D2",SOD-323_L1.7-W1.3-LS2.5-BI,10,3.3V ESD,C46551335
"F1",F0603,10,PTC(40R),C1884486
"L1",IND-SMD_L3.0-W3.0_SWPA3010S,10,10uH/920mA,C45403
"Q1",SOT-23,10,MMBT3906,C727128
"R1",R0402,10,75K,C144737
"R10, R11, R12, R13, R17, R18, R2, R21, R22, R23, R24, R25, R26",R0402,130,51R,C137960
"R14",R0402,10,1K,C11702
"R15, R16, R19, R27, R28, R30, R31, R7, R8",R0402,90,10K,C25744
"R29",R0402,10,20k,C25765
"R3",R0402,10,100K,C25741
"R32, R9",R0402,20,0R,C60485
"R4",R0402,10,30K,C25776
"R5",R0603,10,100R,C110091
"R6",R0402,10,24K,C138026
"U1",SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR,10,ETA2845S2G_C22362741,C22362741
"U2",LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL,10,GD32F303CCT6,C116151
"U3",LGA-14_L3.0-W2.5-P0.50-BR,10,LSM6DSV16XTR,C5267406
"U4",SOT-23-5,10,SN74LVC1G126DBVR,C46472327
"U5",SOT-23-5,10,SN74LVC1G125DBV,C3040625
"U6",SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,10,ME6211C18M5G-N,C236671
"X1",CRYSTAL-SMD_4P-L3.2-W2.5-BL,10,XL2EL89CSI-111YLC-12M,C5280576

## KiCad design hardware/banana_pcb/banana_pcb.kicad_pcb

File hardware/banana_pcb/README.md:

# "banana_pcb" 电池转接板

> "banana_pcb"固定在电池上方，用于转接电池电力的输出到其他板子

- **推荐连接器尺寸**：2.5mm香蕉头PCB连接器13mm，尾部1.5mm（参考型号U6068）
- **引出导线不要太细，正常运行电流3-5A**

## 其他信息
 - 使用KiCAD 9设计.

Parts:
J1, J2: banana_pin
J3: pad-2(surf)

Connections:
unnamed: J1.1, J3.1
unnamed: J2.1, J3.2

Board: 2 copper layers, 39.2 x 6.8 mm, 3 parts (0 on the bottom side), 2 nets.

## Code that names these connections

File firmware/v1/src/board.h (part):

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
    v1 runs on a bare GD32F303CC development board, so:
      * the SPI IMU is not fitted - src/imu_sim.c synthesises the sensor block;
      * USART1 (PA2/PA3) is the real motor bus and stays wired as such;
      * USART0 (PB6/PB7, on the host as /dev/ttyUSB0) doubles as the debug
        console AND as a bus mirror, so the PC test tool can exercise the
        protocol before the real PCBA comes back.  See BUS_MIRROR_ENABLE.

    Pin map (final hardware, `elec_imu_to_dxl/imu_to_dxl/imu_to_dxl.kicad_sch`):

      PA2  USART1_TX   motor bus, half duplex through the auto-direction
                       buffer (TXD_EN is generated from TX, no GPIO involved)
      PA3  USART1_RX   motor bus receive
      PA4  SPI0_NSS    IMU chip select (active low)
      PA5  SPI0_SCK    IMU clock
      PA6  SPI0_MISO   IMU data out
      PA7  SPI0_MOSI   IMU data in
      PB0  INT1        IMU interrupt 1
      PB1  INT2        IMU interrupt 2
      PB6  USART0_TX   debug / bus mirror (host: /dev/ttyUSB0)
      PB7  USART0_RX   debug / bus mirror
      PB5  LED         development-board indicator (STATUS_LED_ENABLE)
*/

#ifndef BOARD_H
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#define DBG_ENABLE              1
#endif

/* USART0 (PB6/PB7) is the *debug console* and nothing else: it prints DBG_*
   lines so a problem can be found.  Every bus transaction - the register
   protocol and the field upgrade - belongs to USART1 (PA2/PA3), the single
   wire motor bus this node shares with the servos (`docs/upgrade.md` §1,
   `docs/imu_to_dxl_protocol.md` §2).

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#define BUS_MIRROR_ENABLE       0
#endif

/* PB5 status LED, active high.  Only the development board has it. */
#ifndef STATUS_LED_ENABLE
#define STATUS_LED_ENABLE       1
#endif
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#define IMU_SCK_PIN             GPIO_PIN_5
#define IMU_MISO_PIN            GPIO_PIN_6
#define IMU_MOSI_PIN            GPIO_PIN_7
#define IMU_INT1_GPIO           GPIOB
#define IMU_INT1_PIN            GPIO_PIN_0
#define IMU_INT2_GPIO           GPIOB
#define IMU_INT2_PIN            GPIO_PIN_1

/* ── protocol constants shared by the two slaves ────────────────────────── */

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